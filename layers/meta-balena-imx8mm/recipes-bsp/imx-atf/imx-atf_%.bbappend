do_configure[nostamp] = "1"
do_compile[nostamp] = "1"
