INTERNAL_DEVICE_KERNEL = "mmcblk2"
