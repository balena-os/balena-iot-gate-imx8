PACKAGE_INSTALL:append = " initramfs-module-rollback-fixup"
