include resin-image.inc

RESIN_BOOT_PARTITION_FILES_append_iot-gate-imx8 = " \
    boot.scr:/boot.scr \
"